* NGSPICE file created from mult4_SARSA_RUIDO_e9_SarsaNada_e6_SARSA_RUIDO_e9_SARSA_RUIDO_e9.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

.subckt mult4_SARSA_RUIDO_e9_SarsaNada_e6_SARSA_RUIDO_e9_SARSA_RUIDO_e9 A[0] A[1]
+ A[2] A[3] B[0] B[1] B[2] B[3] P[0] P[1] P[2] P[3] P[4] P[5] P[6] P[7] VGND VPWR
XFILLER_3_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_062_ net1 net2 net8 net7 VGND VGND VPWR VPWR _010_ sky130_fd_sc_hd__and4_1
XFILLER_3_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_4_Left_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_061_ _008_ VGND VGND VPWR VPWR _009_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput10 net10 VGND VGND VPWR VPWR P[1] sky130_fd_sc_hd__buf_2
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_060_ net7 net3 VGND VGND VPWR VPWR _008_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput11 net11 VGND VGND VPWR VPWR P[2] sky130_fd_sc_hd__buf_2
Xoutput9 net9 VGND VGND VPWR VPWR P[0] sky130_fd_sc_hd__buf_2
XFILLER_5_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput12 net12 VGND VGND VPWR VPWR P[3] sky130_fd_sc_hd__buf_2
XFILLER_7_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Left_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput13 net13 VGND VGND VPWR VPWR P[4] sky130_fd_sc_hd__buf_2
XFILLER_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput14 net14 VGND VGND VPWR VPWR P[5] sky130_fd_sc_hd__buf_2
XFILLER_4_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_099_ _035_ _037_ VGND VGND VPWR VPWR _045_ sky130_fd_sc_hd__nor2_1
Xoutput15 net15 VGND VGND VPWR VPWR P[6] sky130_fd_sc_hd__buf_2
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_098_ net8 net4 _008_ VGND VGND VPWR VPWR _044_ sky130_fd_sc_hd__and3_1
Xoutput16 net16 VGND VGND VPWR VPWR P[7] sky130_fd_sc_hd__buf_2
XFILLER_3_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_097_ _026_ _041_ _042_ _039_ VGND VGND VPWR VPWR _043_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_0_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_096_ _024_ _029_ _030_ _040_ VGND VGND VPWR VPWR _042_ sky130_fd_sc_hd__a31o_1
XFILLER_1_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Left_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_079_ _016_ _017_ _025_ VGND VGND VPWR VPWR _027_ sky130_fd_sc_hd__a21o_1
XFILLER_7_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_095_ _032_ _041_ VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__xnor2_1
XFILLER_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_078_ _016_ _017_ _025_ VGND VGND VPWR VPWR _026_ sky130_fd_sc_hd__and3_1
XFILLER_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_094_ _038_ _040_ VGND VGND VPWR VPWR _041_ sky130_fd_sc_hd__xnor2_1
XFILLER_7_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_077_ _021_ _023_ _019_ VGND VGND VPWR VPWR _025_ sky130_fd_sc_hd__a21o_1
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_093_ _009_ _015_ _014_ VGND VGND VPWR VPWR _040_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_7_Left_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput1 A[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
X_076_ _019_ _022_ _021_ VGND VGND VPWR VPWR _024_ sky130_fd_sc_hd__or3b_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_059_ _003_ _007_ VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__xnor2_1
X_092_ _038_ VGND VGND VPWR VPWR _039_ sky130_fd_sc_hd__inv_2
XFILLER_1_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput2 A[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_075_ _011_ _018_ _002_ VGND VGND VPWR VPWR _023_ sky130_fd_sc_hd__a21o_1
X_058_ _005_ _006_ VGND VGND VPWR VPWR _007_ sky130_fd_sc_hd__and2b_1
X_091_ _034_ _036_ VGND VGND VPWR VPWR _038_ sky130_fd_sc_hd__xor2_2
Xinput3 A[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__dlymetal6s2s_1
X_074_ _011_ _018_ _002_ VGND VGND VPWR VPWR _022_ sky130_fd_sc_hd__a21oi_1
X_057_ _000_ _001_ _004_ net7 VGND VGND VPWR VPWR _006_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput4 A[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
X_090_ _033_ _036_ net8 net3 VGND VGND VPWR VPWR _037_ sky130_fd_sc_hd__and4bb_1
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_056_ net7 _000_ _001_ _004_ VGND VGND VPWR VPWR _005_ sky130_fd_sc_hd__and4_1
X_073_ _020_ net3 net6 VGND VGND VPWR VPWR _021_ sky130_fd_sc_hd__and3b_1
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput5 B[0] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_1
X_072_ net6 net5 net4 net3 VGND VGND VPWR VPWR _020_ sky130_fd_sc_hd__and4_1
X_055_ net1 net8 net2 VGND VGND VPWR VPWR _004_ sky130_fd_sc_hd__a21bo_1
X_071_ _002_ _011_ _018_ VGND VGND VPWR VPWR _019_ sky130_fd_sc_hd__and3_1
Xinput6 B[1] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_2_Left_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_054_ net5 net3 VGND VGND VPWR VPWR _003_ sky130_fd_sc_hd__nand2_1
XFILLER_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_070_ net1 net8 net7 net2 VGND VGND VPWR VPWR _018_ sky130_fd_sc_hd__a22o_1
Xinput7 B[2] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_2
XFILLER_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_053_ _002_ net1 net6 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__and3b_1
X_105_ _031_ _048_ VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__nor2_1
XFILLER_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput8 B[3] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_2
X_052_ net6 net5 net1 net2 VGND VGND VPWR VPWR _002_ sky130_fd_sc_hd__and4_1
X_104_ _024_ _030_ _029_ VGND VGND VPWR VPWR _048_ sky130_fd_sc_hd__a21oi_1
XFILLER_5_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Left_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_051_ net6 net2 VGND VGND VPWR VPWR _001_ sky130_fd_sc_hd__and2_1
XFILLER_2_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_103_ _043_ _046_ _047_ VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_102_ _009_ _035_ _037_ net4 net8 VGND VGND VPWR VPWR _047_ sky130_fd_sc_hd__o311a_1
X_050_ _000_ VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__inv_2
XFILLER_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_101_ _043_ _046_ VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__xor2_1
XFILLER_5_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_45 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_100_ _044_ _045_ VGND VGND VPWR VPWR _046_ sky130_fd_sc_hd__xnor2_1
XFILLER_8_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_1_Left_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_089_ _010_ _020_ VGND VGND VPWR VPWR _036_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_088_ _010_ _020_ VGND VGND VPWR VPWR _035_ sky130_fd_sc_hd__and2_1
XFILLER_8_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_087_ _033_ net3 net8 VGND VGND VPWR VPWR _034_ sky130_fd_sc_hd__and3b_1
X_086_ net8 net7 net4 net3 VGND VGND VPWR VPWR _033_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_5_Left_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_069_ _014_ _015_ _009_ VGND VGND VPWR VPWR _017_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_085_ _027_ _031_ _026_ VGND VGND VPWR VPWR _032_ sky130_fd_sc_hd__a21oi_1
X_068_ _009_ _014_ _015_ VGND VGND VPWR VPWR _016_ sky130_fd_sc_hd__nand3_1
XFILLER_5_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_084_ _028_ _031_ VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__xor2_1
XFILLER_0_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_067_ _010_ _012_ _013_ _003_ VGND VGND VPWR VPWR _015_ sky130_fd_sc_hd__a2bb2o_1
XPHY_EDGE_ROW_9_Left_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_083_ _024_ _029_ _030_ VGND VGND VPWR VPWR _031_ sky130_fd_sc_hd__and3_1
X_049_ net5 net1 VGND VGND VPWR VPWR _000_ sky130_fd_sc_hd__nand2_1
X_066_ _012_ _013_ _003_ _011_ VGND VGND VPWR VPWR _014_ sky130_fd_sc_hd__nand4b_1
XFILLER_9_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_082_ _019_ _022_ _021_ VGND VGND VPWR VPWR _030_ sky130_fd_sc_hd__o21bai_1
X_065_ net6 net4 VGND VGND VPWR VPWR _013_ sky130_fd_sc_hd__and2_1
XFILLER_9_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Left_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_081_ net5 net3 _006_ _005_ VGND VGND VPWR VPWR _029_ sky130_fd_sc_hd__a31o_1
XFILLER_9_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_064_ net2 net8 VGND VGND VPWR VPWR _012_ sky130_fd_sc_hd__nand2_1
XFILLER_6_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_080_ _026_ _027_ VGND VGND VPWR VPWR _028_ sky130_fd_sc_hd__and2b_1
X_063_ net1 net2 net8 net7 VGND VGND VPWR VPWR _011_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_2_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
